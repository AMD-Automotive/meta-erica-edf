# Copyright © Advanced Micro Devices, Inc., or its affiliates. All rights reserved.
# SPDX-License-Identifier: MIT
# Contributors: KC
# Maintainer: LT

FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx:"
FILESEXTRAPATHS:prepend:versal-2ve-2vm-vek385-sdt-seg := "${THISDIR}/u-boot-xlnx/versal-2ve-2vm-vek385-sdt-seg:"
FILESEXTRAPATHS:prepend:rave2-baseline := "${THISDIR}/u-boot-xlnx/rave2-baseline:"
FILESEXTRAPATHS:prepend:rave2-baseline-seg := "${THISDIR}/u-boot-xlnx/rave2-baseline:"
FILESEXTRAPATHS:prepend:rave2-baseline-2026-1 := "${THISDIR}/u-boot-xlnx/rave2-baseline-2026-1:"
FILESEXTRAPATHS:prepend:rave2-ecp := "${THISDIR}/u-boot-xlnx/rave2-ecp:"
FILESEXTRAPATHS:prepend:rave2-ecp-2026-1 := "${THISDIR}/u-boot-xlnx/rave2-ecp-2026-1:"
FILESEXTRAPATHS:prepend:rave2-ecp-seg := "${THISDIR}/u-boot-xlnx/rave2-ecp-seg:${THISDIR}/u-boot-xlnx/rave2-ecp:"
FILESEXTRAPATHS:prepend:rave2-display-expansion := "${THISDIR}/u-boot-xlnx/rave2-display-expansion:"
FILESEXTRAPATHS:prepend:rave2-recovery := "${THISDIR}/u-boot-xlnx/rave2-recovery:"
FILESEXTRAPATHS:prepend:vek385-isp := "${THISDIR}/u-boot-xlnx/vek385-isp:"
FILESEXTRAPATHS:prepend:vek385-isp-2026-1 := "${THISDIR}/u-boot-xlnx/vek385-isp-2026-1:"

# Per-machine opt-in: build u-boot against a trimmed DTB (amba_pl stripped).
# Adding the machine name below pulls in the device-tree-uboot recipe and
# redirects BASE_DTS to the trimmed sibling DTB. BOOT.BIN is unaffected.
UBOOT_TRIMMED_DTB_MACHINES = "vek385-isp vek385-isp-2026-1 rave2-baseline rave2-baseline-seg rave2-ecp rave2-ecp-2026-1 rave2-ecp-seg"
require ${@'${THISDIR}/u-boot-xlnx/uboot-trimmed-dtb.inc' if d.getVar('MACHINE') in (d.getVar('UBOOT_TRIMMED_DTB_MACHINES') or '').split() else ''}


SRC_URI:append:rave2-baseline-dphy = " file://0001-Add-mmi-dwc3.patch "

SRC_URI:append:rave2-baseline = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"

SRC_URI:append:rave2-baseline-seg = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"

SRC_URI:append:rave2-baseline-2026-1 = " \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
            file://amd_versal2.h \
            file://amd_edf.h \
            file://edf-env.cfg \
            file://u-boot-misc.cfg \
"

# The 'efi' MACHINE_FEATURE (set in the autogenerated machine conf) pulls in
# aarch64-bootcmd-bootefi.cfg from meta-amd-edf, which forces
# CONFIG_BOOTCOMMAND="bootmenu -e". Drop it for this machine so our
# u-boot-misc.cfg (CONFIG_BOOTCOMMAND="bootmenu") is the sole setter and the
# boot menu behaves identically to rave2-baseline. Applied last, so it wins
# regardless of layer/fragment parse order.
SRC_URI:remove:rave2-baseline-2026-1 = " file://aarch64-bootcmd-bootefi.cfg"

SRC_URI:append:rave2-ecp = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"
SRC_URI:append:rave2-ecp-2026-1 = " \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
            file://amd_versal2.h \
            file://amd_edf.h \
            file://edf-env.cfg \
            file://u-boot-misc.cfg \
"
SRC_URI:remove:rave2-ecp-2026-1 = " file://aarch64-bootcmd-bootefi.cfg"

# Independent copy for the segmented machine (does not inherit :rave2-ecp).
SRC_URI:append:rave2-ecp-seg = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"


SRC_URI:append:rave2-display-expansion = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"

SRC_URI:append:rave2-recovery = " \
            file://0001-Add-mmi-dwc3.patch \
            file://amd_versal2.h \
            file://recovery-fast.cfg \
"

SRC_URI:append:vek385-isp = " \
    file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"

SRC_URI:append:vek385-isp-2026-1 = " \
    file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
    file://amd_edf_no_overlay.h \
"

SRC_URI:append:vek385-yuv = " \
    file://0001-Restrict-dtb-to-a-third-vs-a-quarter.patch \
"

# Override the shared amd_edf.h after do_sys_config copies it.
# Must use do_compile:prepend because do_sys_config:append:versal-2ve-2vm
# has higher override priority and always runs last in do_sys_config.
do_compile:prepend:vek385-isp-2026-1() {
    cp ${WORKDIR}/amd_edf_no_overlay.h ${S}/include/configs/amd_edf.h
}

do_sys_config:append:versal-2ve-2vm() {
    cp ${WORKDIR}/amd_edf.h ${S}/include/configs/amd_edf.h
}

do_sys_config:append:rave2-baseline() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

do_sys_config:append:rave2-baseline-seg() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

do_sys_config:append:rave2-baseline-2026-1() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

do_sys_config:append:rave2-ecp() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

do_sys_config:append:rave2-ecp-2026-1() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

do_sys_config:append:rave2-ecp-seg() {
    cp ${WORKDIR}/amd_versal2.h ${S}/include/configs/amd_versal2.h
}

