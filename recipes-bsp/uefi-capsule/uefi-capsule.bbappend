# Copyright © Advanced Micro Devices, Inc., or its affiliates. All rights reserved.
# SPDX-License-Identifier: MIT
# Contributors: KC, LT
# Maintainer: LT

PRODUCT_NAME:rave2-baseline-2026-1 = "RAVE2"
PRODUCT_GUID:rave2-baseline-2026-1 = "1e59c6dd-a3a8-45ea-89d7-cf95c199f285"
PRODUCT_URL:rave2-baseline-2026-1 = "https://www.sapphiretech.com/en/commercial/edge-plus-vpr_7p100"

PRODUCT_NAME:rave2-ecp-2026-1 = "RAVE2"
PRODUCT_GUID:rave2-ecp-2026-1 = "77e6fde0-713c-417c-bce8-0767635a5f06"
PRODUCT_URL:rave2-ecp-2026-1 = "https://www.sapphiretech.com/en/commercial/edge-plus-vpr_7p100"

PRODUCT_NAME:vek385-isp-2026-1 = "VEK385"
PRODUCT_GUID:vek385-isp-2026-1 = "39bd9743-f30b-447b-849d-127a354a06ed"
PRODUCT_URL:vek385-isp-2026-1 = "https://www.amd.com/en/products/adaptive-socs-and-fpgas/evaluation-boards/vek385.html"
